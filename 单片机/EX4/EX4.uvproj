# Keil uVision project EX4.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: EX4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./source/: DS18B20.c DS1302.c Infrared.c keyboard.c Lcd1602.c LedBuzzer.c main.c Time.c
  group New Group
    ./source/: config.h DS18B20.h DS1302.h Infrared.h keyboard.h Lcd1602.h LedBuzzer.h main.h Time.h
