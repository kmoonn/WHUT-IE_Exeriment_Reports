# Keil uVision project Work2.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Work2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Uart.c STARTUP.A51 main.c Lcd1602.c keyboard.c
